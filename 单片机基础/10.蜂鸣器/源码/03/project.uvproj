# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER\timer;.\USER\key;.\USER\Delay;.\USER\LCD1602;.\USER\uart;.\USER\buzzer
  group Source Group 1
    ./: main.c
    ./USER/Delay/: delay.c
    ./USER/LCD1602/: LCD1602.c
    ./USER/key/: key.c
    ./USER/uart/: uart.c
    ./USER/timer/: timer.c
    ./USER/buzzer/: buzzer.c
