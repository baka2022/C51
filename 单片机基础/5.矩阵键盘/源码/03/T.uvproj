# Keil uVision project T.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: T +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\Delay;.\src\Seg;.\src\LCD1602;.\src\Key
  group user
    ./: main.c
    ./src/Delay/: delay.c
    ./src/Seg/: seg.c
    ./src/LCD1602/: LCD1602.c
    ./src/Key/: key.c
